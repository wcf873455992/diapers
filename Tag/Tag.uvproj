# Keil uVision project Tag.uvproj, settings and files
target TAG (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: Tag +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: MCU_NRF24LE1
  c include: hal\nrf24le1;hal\nrf24l01p;hal;compiler\c51;compiler\common
  group App
    ./: main.c
    ./user/: AHT10.c DHT11.C
  group HAL
    ./hal/: hal_delay.c
    ./hal/nrf24le1/: hal_clk.c hal_rtc.c hal_adc.c hal_nrf_hw.c hal_wdog.c hal_uart.c
    ./hal/nrf24l01p/: hal_nrf.c
